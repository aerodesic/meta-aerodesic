RDEPENDS_${PN} += "framebuffer-ts"

require weston-init-1.0.inc
