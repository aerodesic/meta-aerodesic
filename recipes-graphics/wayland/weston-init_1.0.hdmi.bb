RDEPENDS_${PN} += "framebuffer-lcd"

require weston-init-1.0.inc
