RDEPENDS_${PN} += "framebuffer-hdmi"

require weston-init-1.0.inc
