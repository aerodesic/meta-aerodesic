FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-4.18:"

SRC_URI += " \
	file://vc.cfg \
"

