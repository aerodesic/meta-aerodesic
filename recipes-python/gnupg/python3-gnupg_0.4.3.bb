require python-gnupg.inc

inherit pypi setuptools3
