inherit pypi setuptools3

SRC_URI[md5sum] = "bd1b66481f337df2c9ab520f244b0134"
SRC_URI[sha256sum] = "68910d7c91b982828e0ba062c92c87153ff617d0f5cfe0bf59d3be36a2777f06"

require pi-plates.inc
