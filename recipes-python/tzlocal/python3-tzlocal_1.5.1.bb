inherit setuptools3
require python-tzlocal.inc
