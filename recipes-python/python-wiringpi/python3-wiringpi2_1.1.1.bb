inherit setuptools3

require python-wiringpi2.inc

DEPENDS += "python3-native python3-setuptools-native"
