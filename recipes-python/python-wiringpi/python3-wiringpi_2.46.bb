inherit setuptools3

require python-wiringpi.inc

DEPENDS += "python3-native python3-setuptools-native"
