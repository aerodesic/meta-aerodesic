inherit setuptools

require python-wiringpi.inc

DEPENDS += "python-native python-setuptools-native"
