BBCLASSEXTEND = "native"

RPROVIDES_append_class-native = " ${BPN}-mibs-native"
RRECOMMENDS_append_class-native = " ${BPN}-mibs-native"

