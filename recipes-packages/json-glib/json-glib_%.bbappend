# DEPENDS = "meson ninja glibc"

# inherit meson
