# Fetch some files for overriding configuration of default system.
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

