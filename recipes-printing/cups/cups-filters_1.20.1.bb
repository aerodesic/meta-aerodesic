include cups-filters.inc

SRC_URI[md5sum] = "d626f9d575d8e4c47e1a696d3b4d1a72"
SRC_URI[sha256sum] = "f7b3853f9567e0213b4e1602bc670a626c3060e2a043e31b6dee21174d5469a5"
