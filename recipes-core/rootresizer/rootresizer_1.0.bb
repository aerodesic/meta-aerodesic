#
# Recipe for system updater program
#
SRCREV = "${AUTOREV}"

require rootresizer.inc

