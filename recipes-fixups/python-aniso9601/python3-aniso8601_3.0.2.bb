DESCRIPTION = "aniso8601 for python"
HOMEPAGE = "https://pypi.python.org/pypi/aniso8601/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3022f9b6026a79af5ea513564dacf3ba"

SRC_URI[md5sum] = "f4a3f2bb23d2451cec1c01be96c99163"
SRC_URI[sha256sum] = "7849749cf00ae0680ad2bdfe4419c7a662bef19c03691a19e008c8b9a5267802"

inherit setuptools3 pypi

